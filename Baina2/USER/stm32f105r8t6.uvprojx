# Keil uVision project stm32f105r8t6.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f105r8t6 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\HARDWARE\LED;..\HARDWARE\TIMER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\CAN;..\HARDWARE\STMFLASH;..\HARDWARE\TASK;..\HARDWARE\DWScreen;..\HARDWARE\WDG;..\HARDWARE\AD7924;..\HARDWARE\CAN_SEND;..\HARDWARE\IO;..\HARDWARE\C;..\HARDWARE\BAINA_TASK;..\HARDWARE\DUO_KU;..\HARDWARE\DS18B20
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/AD7924/: AD7924.c
    ../HARDWARE/CAN_SEND/: can_send.c
    ../HARDWARE/DUO_KU/: duo_ku.c
    ../HARDWARE/IO/: io.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BAINA_TASK/: baina_task.c
    ../HARDWARE/DS18B20/: ds18b20.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
